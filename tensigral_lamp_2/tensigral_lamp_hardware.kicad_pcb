# Repository cnlohr/tensigral_lamp

File README.md:

# tensigral_lamp
My PCB Tensegrity structure lamp.

## KiCad design tensigral_lamp_2/tensigral_lamp_hardware.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C11, C14, C15, C17, C20: 22nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C10, C12, C13, C16, C22: 22uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C18, C19: 2.2uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20: SK6812-RGBWW; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
J1: USB_B_Micro; USBMicroB-U253-051T-4BH89-F1B
J2: JTAG; RIBBON6SMT_POGO_OR_IDC
J4: WSOUT; PinHeader_1x03_P2.54mm_Vertical
J6: MICJ; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
J8: WS_SEL; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
L1, L2: 10uH; L_2816_7142Metric
MIC1: ZTS6011E
P1: WSIN; SolderWirePad_1x01_Drill1mm
P2: WSOUT; SolderWirePad_1x01_Drill1mm
P3, P4: VLED; SolderWirePad_1x01_Drill1mm
P5, P6: GND; SolderWirePad_1x01_Drill1mm
P9: TOPTOUCH; SolderWirePad_1x01_Drill1mm
P10: AUXTOUCH; SolderWirePad_1x01_Drill1mm
R1, R7, R9: 27k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2, R3, R4, R6: 4.7k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R8: 220k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1: BOOT0; TACTILE10B
T1: TOUCH1; TOUCH_MARK
T2: TOUCH2; TOUCH_MARK
TOUCH1, TOUCH2: TA3; TOUCH_MARK
U1: STM32F042F4Px; TSSOP-20_4.4x6.5mm_P0.65mm
U2: MT2492; SOT-23-6_Handsoldering
U3: NUP4202; SOT-363_SC-70-6
U4: XC6206P360MR; SOT-23
U5: LM321; SOT-23-5

Connections:
+3V3: C19.1, L2.1, U1.16 (VDD), U4.2 (VO)
A0: U1.6 (PA0)
A1: U1.7 (PA1)
A2: U1.8 (PA2)
A3: U1.9 (PA3)
ANA_ADC: J6.1, U1.12 (PA6)
AUXGND: C22.2
AUXU: P10.1
AUXVCC: C22.1
AVCC: C16.1, C17.1, L2.2, MIC1.1, R4.2, R9.2, U1.5 (VDDA), U5.5
D+: J1.3 (D+), U1.18 (PA10/PA12), U3.3, U3.4
D-: J1.2 (D-), U1.17 (PA9/PA11), U3.1, U3.6
NRST: C15.1, J2.5, U1.4 (NRST)
unnamed: C11.1, U2.1 (BS)
unnamed: C11.2, L1.1, U2.6 (SW)
unnamed: C18.1, MIC1.4, R4.1
unnamed: C18.2, R6.1
unnamed: C20.1, J6.2, R8.2, U5.4
unnamed: C20.2, R6.2, R8.1, U5.3
unnamed: D1.2 (DOUT), D2.4 (DIN)
unnamed: D1.4 (DIN), D20.2 (DOUT)
unnamed: D2.2 (DOUT), D3.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: D8.2 (DOUT), D9.4 (DIN)
unnamed: D10.2 (DOUT), D11.4 (DIN)
unnamed: D9.2 (DOUT), D10.4 (DIN)
unnamed: D11.2 (DOUT), D12.4 (DIN)
unnamed: D12.2 (DOUT), D13.4 (DIN)
unnamed: D13.2 (DOUT), D14.4 (DIN)
unnamed: D14.2 (DOUT), D15.4 (DIN)
unnamed: D15.2 (DOUT), D16.4 (DIN)
unnamed: D16.2 (DOUT), D17.4 (DIN)
unnamed: D17.2 (DOUT), D18.4 (DIN)
unnamed: D18.2 (DOUT), D19.4 (DIN)
unnamed: D19.2 (DOUT), D20.4 (DIN)
unnamed: R1.1, R2.2, U2.3 (FB)
unnamed: R3.2, SW1.4, U1.1 (PB8)
unnamed: R7.2, R9.1, U5.1
PA1: T2.1
PA3: T1.1
PF0: U1.2 (PF0)
PF1: U1.3 (PF1)
SWC_TX: J2.3, U1.20 (PA14)
SWD: J2.1, U1.19 (PA13)
TIM3_CH4: U1.14 (PB1)
TTVAL: P9.1, TOUCH1.1, TOUCH2.1
VLED: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C12.1, D1.1 (VDD), D2.1 (VDD), D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), D9.1 (VDD), D10.1 (VDD), D11.1 (VDD), D12.1 (VDD), D13.1 (VDD), D14.1 (VDD), D15.1 (VDD), D16.1 (VDD), D17.1 (VDD), D18.1 (VDD), D19.1 (VDD), D20.1 (VDD), L1.2, P3.1, P4.1, R1.2, SW1.1, U4.3 (VI)
VUSB: C13.1, C14.1, J1.1 (VBUS), J2.2, J4.1, U2.4 (EN), U2.5 (IN), U3.5
WS2812: D4.4 (DIN), J4.2, J8.1, P1.1, U1.13 (PA7)
WS2812STAFF: J8.2
WS2812UM: P2.1

Notes on the sheet:
No external matching impedance needed. Driver contains matching impedance.
Actually +4 v
Differences: * Using opamp in microphone circuit * Putting touch on staff. * 90 degree mounting of inside strings. * Connecting LEDs before tear-apart for testing.

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
Board: 2 copper layers, 99.0 x 99.8 mm, 75 parts (2 on the bottom side), 41 nets.

## Commit log

2019-12-24 starting to work on the structure generation
2019-12-24 Bump
2020-01-14 Bump - fixing incorrect button part.
2020-01-31 fix drawing
2020-03-07 rename
2020-03-08 Checkpoint
2020-03-08 touch
2020-05-10 Bump code - fix WS2812 init bug.
2020-05-10 remove lamp2
2020-05-10 Fix off-by-4
2020-05-10 Add binary in case someone doesn't want to build
2020-05-24 Update lamp.
